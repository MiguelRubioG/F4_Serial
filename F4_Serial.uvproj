# Keil uVision project F4_Serial.uvproj, settings and files
target F4_Serial (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: F4_Serial
  c flags: Optim=1
  c include: .\Source;.\Source\Libraries
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Startup/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Libraries
    ./Source/Libraries/: _delay_ms.s _delay_us.s usart1.c usart1.h USART2.c USART2.h
  group Source
    ./Source/: main.c mainUSARTExample.c
